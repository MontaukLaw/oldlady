# IAR project WS2812_S103.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: inc; $TOOLKIT_DIR$\inc\c; $PROJ_DIR$; ws2812b; lis3dh; lis3dh
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: WS2812_S103.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group app
    lis3dh/: gsensor.c rgb.c sys.c
    ./: stm8s_conf.h stm8s_it.c stm8s_it.h
  group Driver
    src/: bsp_adc.c bsp_uart.c SC7A20.c stm8s_adc1.c stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_iwdg.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c
    lis3dh/: bsp_i2c.c lis3dh_driver.c
    ./: ws2812.c
