<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\WS2812_S103.ewp</path>
    </project>
    <batchBuild />
</workspace>
